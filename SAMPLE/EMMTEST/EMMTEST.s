MONITOR		EQU		00B1H
ASC		EQU		05F3H
GETL		EQU		06A4H
GETKEY		EQU		0832H
MSGPR		EQU		0889H
PRNT		EQU		08C6H
DISPCH		EQU		08C6H
DPCT		EQU		08C6H
LETLN		EQU		0A2EH

EMM		EQU		0A4H



		ORG	12A0H

		LD	DE,TITLE			;'******** EMM RAM TEST MENU ********'表示
		CALL	MSGPR
		CALL	LETLN
MENU:		CALL	LETLN
		LD	DE,EMENU			;'0)EMM0 1)EMM1 2)EMM2 3)EMM3 4)EXIT?'表示
		CALL	MSGPR
EKEY:		CALL	GETKEY				;1文字入力待ち
		CP	00H
		JR	Z,EKEY
		LD	B,A
EMM0:		CP	'0'				;EMM0
		JR	NZ,EMM1
		CALL	PRNT
		LD	A,0A0H				;EMM I/Oアドレス A0H
		CALL	EMMADRS
		JR	MENUS
EMM1:		CP	'1'				;EMM1
		JR	NZ,EMM2
		CALL	PRNT
		LD	A,0A4H				;EMM I/Oアドレス A4H
		CALL	EMMADRS
		JR	MENUS
EMM2:		CP	'2'				;EMM2
		JR	NZ,EMM3
		CALL	PRNT
		LD	A,0A8H				;EMM I/Oアドレス A8H
		CALL	EMMADRS
		JR	MENUS
EMM3:		CP	'3'				;EMM3
		JR	NZ,EMM4
		CALL	PRNT
		LD	A,0ACH				;EMM I/Oアドレス ACH
		CALL	EMMADRS
		JR	MENUS
EMM4:		CP	'4'				;EXIT
		JR	NZ,MENU
		CALL	PRNT
		CALL	LETLN
		JR	EXIT
		
	
MENUS:		LD	A,B				;EMM0～EMM3の文字を変更
		LD	(MSG1+3),A
		LD	(MSG4+3),A
MS2:		CALL	LETLN
		JR	LSTART				;EMMTEST

EXIT:
		JP	MONITOR

LSTART:

;********************************** EMMTEST処理本体 ************************************
ST0:		CALL	LETLN
ML1:
		LD	DE,MSG0				;' CHECK START!'表示
		CALL	MSGPR

		XOR	A
		LD	(ADRSL),A
		LD	(ADRSM),A
		LD	(ADRSH),A

		CALL	LETLN
LOP1:
		LD	A,(ADRSL)
		AND	A
		JR	NZ,LOP2
		CALL	PRTADRS
		CALL	LETLN
LOP2:
		CALL	EMMREAD
		LD	(WORK1),A
		LD	A,55H
		CALL	EMMTEST
		CP	55H
		JR	NZ,EMMERR
		LD	A,0AAH
		CALL	EMMTEST
		CP	0AAH
		JR	NZ,EMMERR
		LD	A,(ADRSL)
		CALL	EMMTEST
		LD	HL,ADRSL
		CP	(HL)
		JR	NZ,EMMERR
		LD	A,(WORK1)
		CALL	EMMTEST
		LD	HL,WORK1
		CP	(HL)
		JR	NZ,EMMERR
		LD	HL,(ADRSL)
		INC	HL
		LD	(ADRSL),HL
		LD	A,L
		OR	H
		JR	NZ,LOP1
		LD	A,(ADRSH)
		INC	A
		LD	(ADRSH),A
		CP	08H
		JR	NZ,LOP1
		
		LD	DE,MSG1				;'EMMx MEMORY TEST END'を表示
		CALL	MSGPR
		JP	EXIT				;終了

EMMERR:
		CALL	LETLN
		LD	DE,MSG4				;'EMMx CHECK ERROR!'を表示
		CALL	MSGPR
		JP	EXIT				;終了

EMMTEST:
		CALL	EMMWRITE
		CALL	EMMREAD
		RET

EMMREAD:
		LD	A,(ADRSL)			;EMMアドレスセット
ML2:		OUT	(EMM),A
		LD	A,(ADRSM)
		OUT	(EMM+1),A
		LD	A,(ADRSH)
		OUT	(EMM+2),A
		IN	A,(EMM+3)
		RET

EMMWRITE:
		PUSH	AF
		LD	A,(ADRSL)			;EMMアドレスセット
ML4:		OUT	(EMM),A
		LD	A,(ADRSM)
		OUT	(EMM+1),A
		LD	A,(ADRSH)
		OUT	(EMM+2),A
		POP	AF
		OUT	(EMM+3),A
		RET

EMMADRS:
		LD	(ML2+1),A
		LD	(ML4+1),A
		INC	A
		LD	(ML2+6),A
		LD	(ML4+6),A
		INC	A
		LD	(ML2+11),A
		LD	(ML4+11),A
		INC	A
		LD	(ML2+13),A
		LD	(ML4+14),A
		RET

PRTADRS:
		LD	A,(ADRSH)
		CALL	PRTBYT
		LD	A,(ADRSM)
		CALL	PRTBYT
		LD	A,(ADRSL)
		CALL	PRTBYT
		RET
		
PRTBYT:
		PUSH	AF
		SRL	A
		SRL	A
		SRL	A
		SRL	A
		CALL	ASC
		CALL	PRNT
		POP	AF
		PUSH	AF
		CALL	ASC
		CALL	PRNT
		POP	AF
		RET

TITLE:
		DB	'******** EMM RAM TEST MENU ********'
		DB	0DH

EMENU:		DB	'0)EMM0 1)EMM1 2)EMM2 3)EMM3 4)EXIT?'
		DB	0DH

MSG0:		DB	' EMM RAM TEST START!'
		DB	0DH

MSG1:
		DB	'EMM1 RAM OK!'
		DB	0DH

MSG4:
		DB	'EMM1 RAM ERROR!'
		DB	0DH

ADRSL:		DB	00H
ADRSM:		DB	00H
ADRSH:		DB	00H
WORK1:		DB	00H

		END

